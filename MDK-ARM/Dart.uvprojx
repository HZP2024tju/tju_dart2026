# Keil uVision project Dart.uvprojx, settings and files
target Dart (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Dart +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../bsp/boards;../application;../Components;../Components/Algorithm/Include;../Components/Controller;../Components/Algorithm;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ..\Core\Inc;../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Components/: fifo.c
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group application
    ../application/: referee.c CAN_receive.c dart_task.c remote_control.c servo.c view.c force.c judge.c referee_usart_task.c my_usart.c raspberrypi.c
  group bsp
    ../bsp/boards/: bsp_can.c bsp_usart.c bsp_rc.c bsp_dwt.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Controller
    ../Components/Controller/: controller.c
    ../Components/: user_lib.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.0
